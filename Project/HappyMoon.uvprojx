# Keil uVision project HappyMoon.uvprojx, settings and files
target HappyMoon (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4, __FPU_PRESENT=1, __FPU_USED =1, __CC_ARM
  c include: ..\Core;..\Driver;..\Libraries\inc;..\System;..\User;..\uCOS-III\Bsp;..\uCOS-III\Config;..\uCOS-III\Core;..\uCOS-III\CPU;..\uCOS-III\Lib;..\uCOS-III\Port;..\Libraries\CMSIS\Include;..\Libraries\USB;..\Libraries\USB\STM32_USB_OTG_Driver\inc;..\Libraries\USB\STM32_USB_Device_Library\Class\cdc\inc;..\Libraries\USB\STM32_USB_Device_Library\Core\inc;..\Sensor;..\Hardware;..\Message;..\Parameter;..\Mymath;..\Control;..\Navigation
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Core
    ../Core/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group Libraries
    ../Libraries/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_adc.c
    ../Libraries/inc/: misc.h
  group System
    ../System/: explore_system.c explore_systick.c
  group uC/OS III - BSP
    ../uCOS-III/Bsp/: bsp.c
  group uC/OS III - CPU
    ../uCOS-III/CPU/: cpu_core.c cpu_c.c cpu_a.asm
  group uC/OS III - Lib
    ../uCOS-III/Lib/: lib_ascii.c lib_math.c lib_mem.c lib_str.c lib_mem_a.asm
  group uC/OS III - Core
    ../uCOS-III/Core/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC/OS III - Port
    ../uCOS-III/Port/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC/OS III - Config
    ../uCOS-III/Config/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group User
    ../User/: stm32f4xx_main.c stm32f4xx_conf.h stm32f4xx_it.c Task.c FlightStatus.c
  group Hardware
    ../Hardware/: Board.c Adc_Battery.c SPI1.c Usart1toOnboardPC.c Usart3toBluetooth.c Uart4toTOF.c mcpwm.c General_Gpio.c Flash.c UsbDriver.c
  group Control
    ../Control/: Attitude_control.c Position_control.c PID_control.c ThrustMixer.c SafeControl.c
  group Message
    ../Message/: Data_PC.c Data_deal.c Visiondata_deal.c Type_conversion.c MemoryMessage.c
  group Mymath
    ../Mymath/: digital_filter.c LevenbergMarquardt.c Vector3.c MathTool.c lowPassFilter.c matrix3.c matrix6.c KalmanVel.c kalman3.c
  group Sensor
    ../Sensor/: Sensor.c MPU6000.c MPU6500.c Accelerometer.c Gyroscope.c TofMiniPlus.c
  group Usb
    ../Libraries/USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
    ../Libraries/USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../Libraries/USB/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
    ../Libraries/USB/: usb_bsp.c usbd_desc.c
  group Parameter
    ../Parameter/: DronePara.h Parameter.c
  group Mission
    ../Mission/: Mission.c
  group Navigation
    ../Navigation/: MahonyAHRS.c Navigation.c
